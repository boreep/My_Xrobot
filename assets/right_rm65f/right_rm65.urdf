Commit message: 补充提交

File: assets/right_rm65f/right_rm65.urdf (robot description, URDF)
Before this commit: robot RM65F-R, 10 links, 9 joints
Joints:
- joint world_to_right_base: origin xyz=0 -0.3 1 rpy=1.570796 -1.169371 0 -> xyz=0 0 0 rpy=0 0 0
